require gdb-cross.inc

DEPENDS = "ncurses-sdk"

inherit sdk

PR = "r2"

do_stage() {
	:
}
