SECTION = "libs"

inherit native

require libio-tty-perl_${PV}.bb
