SECTION = "libs"

inherit native

require libexpect-perl_${PV}.bb
