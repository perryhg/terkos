SECTION = "libs"

require libjson-perl_${PV}.bb

inherit native

